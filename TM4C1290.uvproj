# Keil uVision project TM4C1290.uvproj, settings and files
target C368 (ARM-ADS)
  device: TM4C1290NCZAD Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: TM4C1290 +hex
  AfterMake: fromelf --bin --output .\build\NAD_C358.bin .\build\TM4C1290.axf
  c flags: Optim=1
  c define: PART_TM4C1290NCZAD TARGET_IS_SNOWFLAKE_RA0 NAD_C378
  c include: .\OSAL;.\lib;.\inc;..\MainApp;.\Task;.\application;.\startup;.\Driver;.\MDC;.\usblib;.\usblib\host
  memory RVCT4: ROM 0xd000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\build\TM4C1290.sct
  group Startup
    ./startup/: startup_rvmdk.S bsp.c sys_database.h bsp.h sys_config.h
    ./: sys_head.h
  group lib
    ./lib/: driverlib.lib
    ./usblib/rvmdk/: usblib.lib
  group OSAL
    ./OSAL/: OSAL.c OSAL_Env.c OSAL_Port.c OSAL_Task.c OSAL_Timer.c OSAL_Utility.c OSAL_Console.c OSAL_Soft_IIC.c OSAL_Key.c OSAL_RingBuf.c OSAL_Detect.c
  group Application
    ./application/: main.c serial.c UI.c usb_stick_update.c simple_fs.c
  group Task
    ./Task/: Soft_Timer_Task.c System_Task.c Display_Task.c BT_Task.c MDC_Task.c NAD_Uart_App_Task.c
  group Driver
    ./Driver/: pcm1795.c Src4382.c njw1194.c IR_driver.c EPRom_driver.c 74hc595.c lcd_driver.c
  group MDC
    ./MDC/: Mdc.c Mdc_dio.c Mdc_usb.c Mdc_bt.c Mdc_hdmi.c Mdc_ana.c Mdc_hdmi_v2.c
